# Keil uVision project rp2022_engineer_master_hal.uvprojx, settings and files
target rp2022_engineer_master_hal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: rp2022_engineer_master_hal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;                            ../Drivers/STM32F4xx_HAL_Driver/Inc;                            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                            ../Middlewares/Third_Party/FreeRTOS/Source/include;                            ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                            ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                            ../Drivers/CMSIS/Include;                            ..\Application\Algorithm;                            ..\Application\Device;                            ..\Application\Drive;                            ..\Application\Module;                            ..\Application\Config;                            ..\Application\DSP;                            ..\Application\Control;                            ..\Application\BMI;                            ..\Application\Protocol
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/Control
    ../Application/Control/: heart_beat.c control.c mode_switch.c auto_process.c clamp_control.c tranlation_control.c lifting_control.c cabin_control.c ground_control.c save_control.c output_control.c
  group Application/Module
    ../Application/Module/: clamp.c tranlation.c cabin.c lifting.c ground.c save.c
  group Application/Device
    ../Application/Device/: device.c keyboard.c rc_sensor.c imu_sensor.c motor.c keylight.c pneumatic.c led.c
  group Application/Protocol
    ../Application/Protocol/: can_protocol.c rc_protocol.c judge_protocol.c
  group Application/Driver
    ../Application/Drive/: drv_can.c drv_haltick.c drv_uart.c drv_io.c
  group Application/BMI
    ../Application/BMI/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c soft_iic.c
  group Application/Algorihm
    ../Application/Algorithm/: pid.c crc.c filter.c
  group Application/Config
    ../Application/Config/: config.h config.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
